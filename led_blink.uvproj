# Keil uVision project led_blink.uvproj, settings and files
target Target 1 (MCS-251)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(11059200)
  group Source Group 1
    ./: main.c
